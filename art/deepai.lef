VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO deepai
  CLASS BLOCK ;
  FOREIGN deepai ;
  ORIGIN 0.000 0.000 ;
  SIZE 244.800 BY 241.200 ;
  OBS
      LAYER Metal5 ;
        RECT 114.000 226.200 124.800 226.800 ;
        RECT 180.000 226.200 184.200 226.800 ;
        RECT 112.200 225.600 130.200 226.200 ;
        RECT 176.400 225.600 187.200 226.200 ;
        RECT 109.800 225.000 132.600 225.600 ;
        RECT 174.000 225.000 189.600 225.600 ;
        RECT 102.000 224.400 140.400 225.000 ;
        RECT 169.200 224.400 195.000 225.000 ;
        RECT 100.800 223.800 141.600 224.400 ;
        RECT 168.000 223.800 196.800 224.400 ;
        RECT 99.000 223.200 143.400 223.800 ;
        RECT 166.800 223.200 198.000 223.800 ;
        RECT 95.400 222.600 148.800 223.200 ;
        RECT 163.800 222.600 200.400 223.200 ;
        RECT 93.600 222.000 150.000 222.600 ;
        RECT 162.600 222.000 201.600 222.600 ;
        RECT 93.000 221.400 151.200 222.000 ;
        RECT 162.000 221.400 202.800 222.000 ;
        RECT 90.000 220.800 154.200 221.400 ;
        RECT 160.200 220.800 204.600 221.400 ;
        RECT 88.800 220.200 155.400 220.800 ;
        RECT 159.600 220.200 205.200 220.800 ;
        RECT 88.200 219.600 156.000 220.200 ;
        RECT 158.400 219.600 206.400 220.200 ;
        RECT 85.800 219.000 207.600 219.600 ;
        RECT 84.600 218.400 208.800 219.000 ;
        RECT 84.000 217.800 209.400 218.400 ;
        RECT 82.800 217.200 210.600 217.800 ;
        RECT 81.600 216.600 211.200 217.200 ;
        RECT 81.000 216.000 212.400 216.600 ;
        RECT 79.200 215.400 213.600 216.000 ;
        RECT 78.600 214.800 214.200 215.400 ;
        RECT 78.000 214.200 214.800 214.800 ;
        RECT 76.200 213.600 215.400 214.200 ;
        RECT 75.600 213.000 216.000 213.600 ;
        RECT 75.000 212.400 216.600 213.000 ;
        RECT 73.800 211.800 217.800 212.400 ;
        RECT 73.200 211.200 218.400 211.800 ;
        RECT 72.600 210.600 219.000 211.200 ;
        RECT 71.400 210.000 219.600 210.600 ;
        RECT 70.800 209.400 220.200 210.000 ;
        RECT 70.200 208.800 220.800 209.400 ;
        RECT 69.000 208.200 221.400 208.800 ;
        RECT 68.400 207.600 222.000 208.200 ;
        RECT 67.800 207.000 222.600 207.600 ;
        RECT 67.200 206.400 223.200 207.000 ;
        RECT 66.600 205.800 223.800 206.400 ;
        RECT 66.000 205.200 224.400 205.800 ;
        RECT 65.400 204.600 225.000 205.200 ;
        RECT 64.800 204.000 225.600 204.600 ;
        RECT 64.200 203.400 226.200 204.000 ;
        RECT 63.600 202.800 226.200 203.400 ;
        RECT 63.000 202.200 226.800 202.800 ;
        RECT 62.400 201.600 226.800 202.200 ;
        RECT 61.800 201.000 226.800 201.600 ;
        RECT 61.200 200.400 226.200 201.000 ;
        RECT 60.600 199.800 226.200 200.400 ;
        RECT 60.000 199.200 225.000 199.800 ;
        RECT 60.000 198.600 224.400 199.200 ;
        RECT 59.400 198.000 223.800 198.600 ;
        RECT 58.800 197.400 217.200 198.000 ;
        RECT 58.200 196.800 215.400 197.400 ;
        RECT 57.600 196.200 214.200 196.800 ;
        RECT 57.600 195.600 210.000 196.200 ;
        RECT 57.000 195.000 209.400 195.600 ;
        RECT 56.400 194.400 208.200 195.000 ;
        RECT 55.800 193.800 205.800 194.400 ;
        RECT 55.800 193.200 204.600 193.800 ;
        RECT 55.200 192.600 204.000 193.200 ;
        RECT 54.600 192.000 202.200 192.600 ;
        RECT 54.600 191.400 201.600 192.000 ;
        RECT 54.000 190.800 201.000 191.400 ;
        RECT 54.000 190.200 200.400 190.800 ;
        RECT 54.000 189.600 199.800 190.200 ;
        RECT 53.400 189.000 200.400 189.600 ;
        RECT 52.800 188.400 200.400 189.000 ;
        RECT 52.200 187.800 201.000 188.400 ;
        RECT 52.200 186.600 201.600 187.800 ;
        RECT 52.200 186.000 202.200 186.600 ;
        RECT 51.600 185.400 202.800 186.000 ;
        RECT 51.600 184.800 203.400 185.400 ;
        RECT 51.000 184.200 203.400 184.800 ;
        RECT 51.000 183.600 204.000 184.200 ;
        RECT 50.400 183.000 204.600 183.600 ;
        RECT 50.400 181.800 205.200 183.000 ;
        RECT 50.400 180.600 205.800 181.800 ;
        RECT 50.400 180.000 206.400 180.600 ;
        RECT 50.400 179.400 207.000 180.000 ;
        RECT 49.800 178.800 207.000 179.400 ;
        RECT 49.800 178.200 207.600 178.800 ;
        RECT 49.800 177.600 208.200 178.200 ;
        RECT 49.200 175.800 208.800 177.600 ;
        RECT 49.200 175.200 209.400 175.800 ;
        RECT 48.600 174.000 210.000 175.200 ;
        RECT 48.600 172.800 210.600 174.000 ;
        RECT 48.600 172.200 211.200 172.800 ;
        RECT 48.600 171.000 211.800 172.200 ;
        RECT 48.600 169.800 212.400 171.000 ;
        RECT 49.200 169.200 213.000 169.800 ;
        RECT 49.200 168.000 213.600 169.200 ;
        RECT 49.200 166.800 214.200 168.000 ;
        RECT 49.800 166.200 214.200 166.800 ;
        RECT 49.800 165.600 214.800 166.200 ;
        RECT 49.800 164.400 215.400 165.600 ;
        RECT 49.800 163.800 216.000 164.400 ;
        RECT 50.400 162.600 216.000 163.800 ;
        RECT 50.400 161.400 216.600 162.600 ;
        RECT 50.400 160.800 217.200 161.400 ;
        RECT 50.400 159.600 217.800 160.800 ;
        RECT 51.000 158.400 217.800 159.600 ;
        RECT 51.000 157.800 218.400 158.400 ;
        RECT 51.600 157.200 218.400 157.800 ;
        RECT 51.600 156.600 219.000 157.200 ;
        RECT 52.200 156.000 219.000 156.600 ;
        RECT 52.200 154.800 219.600 156.000 ;
        RECT 52.200 154.200 133.800 154.800 ;
        RECT 137.400 154.200 219.600 154.800 ;
        RECT 52.800 153.600 129.000 154.200 ;
        RECT 142.200 153.600 219.600 154.200 ;
        RECT 52.800 153.000 125.400 153.600 ;
        RECT 145.800 153.000 220.200 153.600 ;
        RECT 53.400 152.400 117.600 153.000 ;
        RECT 152.400 152.400 220.200 153.000 ;
        RECT 54.000 151.800 115.800 152.400 ;
        RECT 153.600 151.800 220.800 152.400 ;
        RECT 54.000 151.200 114.600 151.800 ;
        RECT 154.800 151.200 220.800 151.800 ;
        RECT 54.000 150.600 111.000 151.200 ;
        RECT 157.200 150.600 221.400 151.200 ;
        RECT 54.000 150.000 109.800 150.600 ;
        RECT 158.400 150.000 221.400 150.600 ;
        RECT 54.600 149.400 109.200 150.000 ;
        RECT 159.600 149.400 221.400 150.000 ;
        RECT 55.200 148.800 106.800 149.400 ;
        RECT 162.000 148.800 221.400 149.400 ;
        RECT 55.200 148.200 105.600 148.800 ;
        RECT 162.600 148.200 221.400 148.800 ;
        RECT 55.800 147.600 105.000 148.200 ;
        RECT 163.800 147.600 221.400 148.200 ;
        RECT 55.800 147.000 102.600 147.600 ;
        RECT 166.200 147.000 222.000 147.600 ;
        RECT 56.400 146.400 102.000 147.000 ;
        RECT 166.800 146.400 222.000 147.000 ;
        RECT 56.400 145.800 100.800 146.400 ;
        RECT 168.000 145.800 222.600 146.400 ;
        RECT 57.000 145.200 99.000 145.800 ;
        RECT 169.200 145.200 222.600 145.800 ;
        RECT 57.600 144.600 98.400 145.200 ;
        RECT 170.400 144.600 223.200 145.200 ;
        RECT 57.600 144.000 97.800 144.600 ;
        RECT 171.000 144.000 223.200 144.600 ;
        RECT 58.200 143.400 96.000 144.000 ;
        RECT 172.200 143.400 223.200 144.000 ;
        RECT 58.800 142.800 95.400 143.400 ;
        RECT 173.400 142.800 223.200 143.400 ;
        RECT 58.800 142.200 94.800 142.800 ;
        RECT 174.000 142.200 223.200 142.800 ;
        RECT 59.400 141.600 93.600 142.200 ;
        RECT 175.200 141.600 223.200 142.200 ;
        RECT 59.400 141.000 93.000 141.600 ;
        RECT 176.400 141.000 223.200 141.600 ;
        RECT 59.400 140.400 92.400 141.000 ;
        RECT 177.000 140.400 223.800 141.000 ;
        RECT 59.400 139.800 91.200 140.400 ;
        RECT 177.600 139.800 223.800 140.400 ;
        RECT 59.400 139.200 90.600 139.800 ;
        RECT 178.200 139.200 223.800 139.800 ;
        RECT 59.400 138.600 90.000 139.200 ;
        RECT 178.800 138.600 224.400 139.200 ;
        RECT 59.400 138.000 88.800 138.600 ;
        RECT 180.000 138.000 224.400 138.600 ;
        RECT 59.400 137.400 88.200 138.000 ;
        RECT 180.600 137.400 224.400 138.000 ;
        RECT 58.800 136.800 87.600 137.400 ;
        RECT 181.200 136.800 225.000 137.400 ;
        RECT 58.200 136.200 87.000 136.800 ;
        RECT 181.800 136.200 225.000 136.800 ;
        RECT 58.200 135.600 86.400 136.200 ;
        RECT 182.400 135.600 225.000 136.200 ;
        RECT 57.600 135.000 85.200 135.600 ;
        RECT 183.000 135.000 225.000 135.600 ;
        RECT 57.600 134.400 84.600 135.000 ;
        RECT 184.200 134.400 225.000 135.000 ;
        RECT 57.600 133.800 84.000 134.400 ;
        RECT 184.800 133.800 225.000 134.400 ;
        RECT 57.600 133.200 83.400 133.800 ;
        RECT 57.000 132.600 82.200 133.200 ;
        RECT 185.400 132.600 225.000 133.800 ;
        RECT 56.400 132.000 81.600 132.600 ;
        RECT 186.000 132.000 225.000 132.600 ;
        RECT 56.400 131.400 80.400 132.000 ;
        RECT 186.600 131.400 225.000 132.000 ;
        RECT 55.800 130.800 79.800 131.400 ;
        RECT 187.200 130.800 225.000 131.400 ;
        RECT 55.800 130.200 79.200 130.800 ;
        RECT 187.800 130.200 225.000 130.800 ;
        RECT 55.800 129.600 78.600 130.200 ;
        RECT 188.400 129.600 225.600 130.200 ;
        RECT 55.800 129.000 78.000 129.600 ;
        RECT 55.800 128.400 77.400 129.000 ;
        RECT 189.000 128.400 225.600 129.600 ;
        RECT 55.200 127.800 76.800 128.400 ;
        RECT 189.600 127.800 225.600 128.400 ;
        RECT 55.200 127.200 76.200 127.800 ;
        RECT 190.200 127.200 226.200 127.800 ;
        RECT 54.600 126.600 75.600 127.200 ;
        RECT 190.800 126.600 226.200 127.200 ;
        RECT 54.600 126.000 74.400 126.600 ;
        RECT 191.400 126.000 226.200 126.600 ;
        RECT 54.000 125.400 73.800 126.000 ;
        RECT 192.000 125.400 226.200 126.000 ;
        RECT 54.000 124.800 73.200 125.400 ;
        RECT 192.600 124.800 226.200 125.400 ;
        RECT 54.000 124.200 72.600 124.800 ;
        RECT 192.600 124.200 226.800 124.800 ;
        RECT 54.000 123.600 72.000 124.200 ;
        RECT 54.000 123.000 71.400 123.600 ;
        RECT 193.200 123.000 226.800 124.200 ;
        RECT 54.000 122.400 70.800 123.000 ;
        RECT 193.800 122.400 226.800 123.000 ;
        RECT 54.000 121.800 70.200 122.400 ;
        RECT 54.000 121.200 69.600 121.800 ;
        RECT 194.400 121.200 226.800 122.400 ;
        RECT 54.000 120.600 69.000 121.200 ;
        RECT 195.000 120.600 226.800 121.200 ;
        RECT 54.000 120.000 68.400 120.600 ;
        RECT 54.000 119.400 67.800 120.000 ;
        RECT 195.600 119.400 226.800 120.600 ;
        RECT 54.000 118.800 67.200 119.400 ;
        RECT 54.000 118.200 66.000 118.800 ;
        RECT 196.200 118.200 226.800 119.400 ;
        RECT 54.000 117.600 65.400 118.200 ;
        RECT 54.000 117.000 64.800 117.600 ;
        RECT 196.800 117.000 226.800 118.200 ;
        RECT 54.600 116.400 64.200 117.000 ;
        RECT 197.400 116.400 226.800 117.000 ;
        RECT 54.600 115.800 63.600 116.400 ;
        RECT 55.800 115.200 63.000 115.800 ;
        RECT 57.000 114.600 61.800 115.200 ;
        RECT 198.000 114.600 226.800 116.400 ;
        RECT 198.600 113.400 226.800 114.600 ;
        RECT 199.200 112.800 226.800 113.400 ;
        RECT 199.800 110.400 226.800 112.800 ;
        RECT 166.800 109.200 167.400 109.800 ;
        RECT 200.400 109.200 226.800 110.400 ;
        RECT 166.200 108.600 171.000 109.200 ;
        RECT 201.000 108.600 226.800 109.200 ;
        RECT 165.600 108.000 172.800 108.600 ;
        RECT 201.000 108.000 226.200 108.600 ;
        RECT 165.600 107.400 177.600 108.000 ;
        RECT 165.600 106.800 178.200 107.400 ;
        RECT 165.600 106.200 179.400 106.800 ;
        RECT 165.600 105.600 181.800 106.200 ;
        RECT 201.600 105.600 226.200 108.000 ;
        RECT 165.600 105.000 182.400 105.600 ;
        RECT 201.600 105.000 225.600 105.600 ;
        RECT 165.600 104.400 183.600 105.000 ;
        RECT 165.600 103.800 184.800 104.400 ;
        RECT 202.200 103.800 225.600 105.000 ;
        RECT 165.600 103.200 185.400 103.800 ;
        RECT 165.600 102.600 186.600 103.200 ;
        RECT 202.800 102.600 225.600 103.800 ;
        RECT 165.600 102.000 187.800 102.600 ;
        RECT 165.600 101.400 188.400 102.000 ;
        RECT 165.600 100.800 189.000 101.400 ;
        RECT 165.600 100.200 190.200 100.800 ;
        RECT 165.600 99.600 190.800 100.200 ;
        RECT 165.600 99.000 191.400 99.600 ;
        RECT 203.400 99.000 225.000 102.600 ;
        RECT 165.600 98.400 192.000 99.000 ;
        RECT 165.600 97.800 192.600 98.400 ;
        RECT 204.000 97.800 225.000 99.000 ;
        RECT 165.600 97.200 193.200 97.800 ;
        RECT 165.600 96.600 194.400 97.200 ;
        RECT 165.000 96.000 194.400 96.600 ;
        RECT 204.600 96.000 225.000 97.800 ;
        RECT 165.000 95.400 195.000 96.000 ;
        RECT 205.200 95.400 225.000 96.000 ;
        RECT 13.200 94.800 37.200 95.400 ;
        RECT 165.000 94.800 195.600 95.400 ;
        RECT 12.600 69.000 37.800 94.800 ;
        RECT 165.000 94.200 196.200 94.800 ;
        RECT 164.400 93.600 196.800 94.200 ;
        RECT 205.200 93.600 224.400 95.400 ;
        RECT 164.400 93.000 197.400 93.600 ;
        RECT 164.400 92.400 198.000 93.000 ;
        RECT 205.200 92.400 223.800 93.600 ;
        RECT 163.800 91.200 198.600 92.400 ;
        RECT 163.800 90.600 199.200 91.200 ;
        RECT 163.800 89.400 199.800 90.600 ;
        RECT 163.800 88.800 200.400 89.400 ;
        RECT 163.800 87.600 201.000 88.800 ;
        RECT 163.800 86.400 201.600 87.600 ;
        RECT 205.200 87.000 223.200 92.400 ;
        RECT 163.200 85.800 202.200 86.400 ;
        RECT 205.200 85.800 222.600 87.000 ;
        RECT 163.200 85.200 202.800 85.800 ;
        RECT 162.600 84.600 202.800 85.200 ;
        RECT 205.200 84.600 222.000 85.800 ;
        RECT 162.600 84.000 203.400 84.600 ;
        RECT 162.000 82.200 203.400 84.000 ;
        RECT 205.200 82.200 221.400 84.600 ;
        RECT 162.000 81.600 204.000 82.200 ;
        RECT 204.600 81.600 221.400 82.200 ;
        RECT 162.000 80.400 221.400 81.600 ;
        RECT 161.400 79.200 220.800 80.400 ;
        RECT 160.800 78.600 220.200 79.200 ;
        RECT 160.200 78.000 220.200 78.600 ;
        RECT 160.200 76.200 219.600 78.000 ;
        RECT 159.600 75.600 219.600 76.200 ;
        RECT 159.000 75.000 219.600 75.600 ;
        RECT 159.000 74.400 219.000 75.000 ;
        RECT 158.400 73.800 219.000 74.400 ;
        RECT 158.400 72.600 218.400 73.800 ;
        RECT 158.400 72.000 217.800 72.600 ;
        RECT 157.800 71.400 217.800 72.000 ;
        RECT 157.200 70.200 217.800 71.400 ;
        RECT 156.600 69.600 217.200 70.200 ;
        RECT 156.600 69.000 216.600 69.600 ;
        RECT 13.200 68.400 37.200 69.000 ;
        RECT 156.000 68.400 216.600 69.000 ;
        RECT 155.400 67.200 216.000 68.400 ;
        RECT 154.800 66.600 216.000 67.200 ;
        RECT 154.800 66.000 215.400 66.600 ;
        RECT 154.200 65.400 215.400 66.000 ;
        RECT 154.200 64.800 214.800 65.400 ;
        RECT 153.600 64.200 214.800 64.800 ;
        RECT 153.000 63.600 214.200 64.200 ;
        RECT 152.400 63.000 214.200 63.600 ;
        RECT 151.800 62.400 214.200 63.000 ;
        RECT 151.800 61.800 213.600 62.400 ;
        RECT 151.200 61.200 213.000 61.800 ;
        RECT 150.600 60.600 213.000 61.200 ;
        RECT 150.000 59.400 212.400 60.600 ;
        RECT 149.400 58.800 211.800 59.400 ;
        RECT 148.800 58.200 211.800 58.800 ;
        RECT 148.200 57.600 211.200 58.200 ;
        RECT 147.600 56.400 210.600 57.600 ;
        RECT 147.000 55.800 210.600 56.400 ;
        RECT 145.800 55.200 210.000 55.800 ;
        RECT 145.800 54.600 209.400 55.200 ;
        RECT 145.200 54.000 209.400 54.600 ;
        RECT 144.600 53.400 208.800 54.000 ;
        RECT 144.000 52.800 208.800 53.400 ;
        RECT 143.400 52.200 208.200 52.800 ;
        RECT 142.200 51.600 207.600 52.200 ;
        RECT 141.600 51.000 207.000 51.600 ;
        RECT 141.000 50.400 206.400 51.000 ;
        RECT 140.400 49.800 205.800 50.400 ;
        RECT 139.200 49.200 205.800 49.800 ;
        RECT 138.600 48.600 205.200 49.200 ;
        RECT 54.600 48.000 55.800 48.600 ;
        RECT 138.000 48.000 205.200 48.600 ;
        RECT 54.600 47.400 56.400 48.000 ;
        RECT 136.800 47.400 204.600 48.000 ;
        RECT 55.200 46.800 57.600 47.400 ;
        RECT 136.200 46.800 204.000 47.400 ;
        RECT 55.800 46.200 58.200 46.800 ;
        RECT 135.600 46.200 203.400 46.800 ;
        RECT 56.400 45.600 59.400 46.200 ;
        RECT 134.400 45.600 203.400 46.200 ;
        RECT 56.400 45.000 60.000 45.600 ;
        RECT 133.800 45.000 202.800 45.600 ;
        RECT 57.000 44.400 61.200 45.000 ;
        RECT 132.000 44.400 202.200 45.000 ;
        RECT 57.600 43.800 61.800 44.400 ;
        RECT 131.400 43.800 201.600 44.400 ;
        RECT 58.200 43.200 62.400 43.800 ;
        RECT 130.800 43.200 201.600 43.800 ;
        RECT 58.800 42.600 64.200 43.200 ;
        RECT 129.600 42.600 201.000 43.200 ;
        RECT 59.400 42.000 64.800 42.600 ;
        RECT 128.400 42.000 200.400 42.600 ;
        RECT 60.000 41.400 66.000 42.000 ;
        RECT 127.800 41.400 199.800 42.000 ;
        RECT 60.600 40.800 67.800 41.400 ;
        RECT 126.000 40.800 199.200 41.400 ;
        RECT 61.200 40.200 68.400 40.800 ;
        RECT 124.800 40.200 199.200 40.800 ;
        RECT 61.800 39.600 69.600 40.200 ;
        RECT 123.600 39.600 198.600 40.200 ;
        RECT 63.000 39.000 72.000 39.600 ;
        RECT 120.600 39.000 198.000 39.600 ;
        RECT 63.000 38.400 73.200 39.000 ;
        RECT 119.400 38.400 197.400 39.000 ;
        RECT 63.600 37.800 73.800 38.400 ;
        RECT 118.800 37.800 196.800 38.400 ;
        RECT 64.800 37.200 76.800 37.800 ;
        RECT 116.400 37.200 196.200 37.800 ;
        RECT 65.400 36.600 78.000 37.200 ;
        RECT 115.200 36.600 195.600 37.200 ;
        RECT 66.000 36.000 79.200 36.600 ;
        RECT 114.000 36.000 195.000 36.600 ;
        RECT 66.600 35.400 82.800 36.000 ;
        RECT 108.600 35.400 194.400 36.000 ;
        RECT 67.200 34.800 84.000 35.400 ;
        RECT 106.800 34.800 193.800 35.400 ;
        RECT 67.800 34.200 85.200 34.800 ;
        RECT 105.000 34.200 193.200 34.800 ;
        RECT 69.000 33.600 192.600 34.200 ;
        RECT 69.600 33.000 192.000 33.600 ;
        RECT 70.200 32.400 191.400 33.000 ;
        RECT 71.400 31.800 190.800 32.400 ;
        RECT 72.000 31.200 190.200 31.800 ;
        RECT 72.600 30.600 189.600 31.200 ;
        RECT 73.800 30.000 189.000 30.600 ;
        RECT 74.400 29.400 187.800 30.000 ;
        RECT 75.000 28.800 187.200 29.400 ;
        RECT 76.200 28.200 186.000 28.800 ;
        RECT 76.800 27.600 185.400 28.200 ;
        RECT 78.000 27.000 184.800 27.600 ;
        RECT 79.200 26.400 183.000 27.000 ;
        RECT 79.800 25.800 182.400 26.400 ;
        RECT 81.000 25.200 181.800 25.800 ;
        RECT 82.200 24.600 180.000 25.200 ;
        RECT 83.400 24.000 179.400 24.600 ;
        RECT 84.000 23.400 178.200 24.000 ;
        RECT 85.800 22.800 177.000 23.400 ;
        RECT 86.400 22.200 176.400 22.800 ;
        RECT 87.600 21.600 175.200 22.200 ;
        RECT 89.400 21.000 173.400 21.600 ;
        RECT 90.000 20.400 172.800 21.000 ;
        RECT 91.200 19.800 171.600 20.400 ;
        RECT 93.000 19.200 169.200 19.800 ;
        RECT 94.200 18.600 168.600 19.200 ;
        RECT 95.400 18.000 167.400 18.600 ;
        RECT 97.800 17.400 165.000 18.000 ;
        RECT 99.000 16.800 163.800 17.400 ;
        RECT 100.200 16.200 162.600 16.800 ;
        RECT 103.800 15.600 159.000 16.200 ;
        RECT 105.000 15.000 157.800 15.600 ;
        RECT 106.800 14.400 156.600 15.000 ;
        RECT 111.000 13.800 151.200 14.400 ;
        RECT 112.800 13.200 149.400 13.800 ;
        RECT 114.000 12.600 148.200 13.200 ;
        RECT 119.400 12.000 141.000 12.600 ;
        RECT 121.800 11.400 138.600 12.000 ;
        RECT 123.600 10.800 136.200 11.400 ;
  END
END deepai
END LIBRARY

